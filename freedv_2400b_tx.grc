options:
  parameters:
    author: Luis / OpenAI Codex
    category: '[Examples]'
    description: FreeDV 2400B transmitter for a VHF FM handheld radio
    generate_options: qt_gui
    id: freedv_2400b_tx
    output_language: python
    title: FreeDV 2400B - TX para HT VHF
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: speech_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Nivel TX hacia el HT
    start: '0.0'
    step: '0.01'
    stop: '1.0'
    value: '0.10'
  states: {}
- name: audio_in
  id: parameter
  parameters:
    label: Dispositivo de micrófono
    type: str
    value: hw:CARD=Headset,DEV=0
  states: {}
- name: audio_out
  id: parameter
  parameters:
    label: Dispositivo hacia el HT
    type: str
    value: default:CARD=Pro
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_out
    samp_rate: audio_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: audio_in
    samp_rate: audio_rate
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_gain
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '2048'
    name: '''Espectro del módem 2400B'''
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '''Audio hacia el HT'''
    size: '2048'
    srate: audio_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    fbw: '0.4'
    interp: '1'
    type: fff
  states: {}
- name: vocoder_freedv_tx_ss_0
  id: vocoder_freedv_tx_ss
  parameters:
    clip_val: 'False'
    interleave_frames: '1'
    mode: freedv_api.MODE_2400B
    tx_bpf_val: 'True'
    txt_msg: '''GNU Radio 2400B'''
  states: {}

connections:
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_short_0, '0', vocoder_freedv_tx_ss_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [vocoder_freedv_tx_ss_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
