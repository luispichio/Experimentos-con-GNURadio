options:
  parameters:
    author: Luis / OpenAI Codex
    category: '[Examples]'
    description: FreeDV 2400B audio loopback with a simulated HT channel
    generate_options: qt_gui
    id: freedv_2400b_loopback
    output_language: python
    title: FreeDV 2400B - Loopback de audio
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: channel_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia del canal
    start: '0.05'
    step: '0.05'
    stop: '1.0'
    value: '0.8'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Ruido del canal
    start: '0.0'
    step: '0.002'
    stop: '0.20'
    value: '0.0'
  states: {}
- name: squelch_enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Squelch FreeDV
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: squelch_thresh
  id: variable_qtgui_range
  parameters:
    label: Umbral de squelch (dB)
    start: '-5.0'
    step: '0.5'
    stop: '20.0'
    value: '2.0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '42'
    type: float
  states: {}
- name: audio_in
  id: parameter
  parameters:
    label: Dispositivo de micrófono
    type: str
    value: default:CARD=Headset
  states: {}
- name: audio_out
  id: parameter
  parameters:
    label: Dispositivo de escucha
    type: str
    value: default:CARD=Headset
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_out
    samp_rate: audio_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: audio_in
    samp_rate: audio_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: channel_gain
    high_cutoff_freq: '3000'
    low_cutoff_freq: '300'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '150'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_short_rx
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_float_to_short_tx
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_short_to_float_modem
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: blocks_short_to_float_speech
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '2048'
    name: '''Espectro después del canal 300-3000 Hz'''
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '''Voz recuperada'''
    size: '2048'
    srate: audio_rate
    type: float
  states: {}
- name: rational_resampler_rx
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: '6'
    type: fff
  states: {}
- name: rational_resampler_tx
  id: rational_resampler_xxx
  parameters:
    decim: '6'
    fbw: '0.4'
    interp: '1'
    type: fff
  states: {}
- name: vocoder_freedv_rx_ss_0
  id: vocoder_freedv_rx_ss
  parameters:
    interleave_frames: '1'
    mode: freedv_api.MODE_2400B
    squelch_enable: squelch_enable
    squelch_thresh: squelch_thresh
  states: {}
- name: vocoder_freedv_tx_ss_0
  id: vocoder_freedv_tx_ss
  parameters:
    clip_val: 'False'
    interleave_frames: '1'
    mode: freedv_api.MODE_2400B
    tx_bpf_val: 'True'
    txt_msg: '''GNU Radio 2400B'''
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [audio_source_0, '0', rational_resampler_tx, '0']
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_float_to_short_rx, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_short_rx, '0', vocoder_freedv_rx_ss_0, '0']
- [blocks_float_to_short_tx, '0', vocoder_freedv_tx_ss_0, '0']
- [blocks_short_to_float_modem, '0', band_pass_filter_0, '0']
- [blocks_short_to_float_speech, '0', rational_resampler_rx, '0']
- [rational_resampler_rx, '0', audio_sink_0, '0']
- [rational_resampler_rx, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_tx, '0', blocks_float_to_short_tx, '0']
- [vocoder_freedv_rx_ss_0, '0', blocks_short_to_float_speech, '0']
- [vocoder_freedv_tx_ss_0, '0', blocks_short_to_float_modem, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
