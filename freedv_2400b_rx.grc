options:
  parameters:
    author: Luis / OpenAI Codex
    category: '[Examples]'
    description: FreeDV 2400B receiver for a VHF FM handheld radio
    generate_options: qt_gui
    id: freedv_2400b_rx
    output_language: python
    title: FreeDV 2400B - RX para HT VHF
  states: {}

blocks:
- name: audio_in
  id: parameter
  parameters:
    label: Dispositivo desde el HT
    type: str
    value: ''''''
  states: {}
- name: audio_out
  id: parameter
  parameters:
    label: Dispositivo de escucha
    type: str
    value: ''''''
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Ganancia de entrada RX
    start: '0.05'
    stop: '4.0'
    step: '0.05'
    value: '1.0'
  states: {}
- name: squelch_enable
  id: variable_qtgui_check_box
  parameters:
    label: Squelch FreeDV
    type: bool
    value: 'True'
    'true': 'True'
    'false': 'False'
  states: {}
- name: squelch_thresh
  id: variable_qtgui_range
  parameters:
    label: Umbral de squelch (dB)
    start: '-5.0'
    stop: '20.0'
    step: '0.5'
    value: '2.0'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: audio_in
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rx_gain
    type: float
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: vocoder_freedv_rx_ss_0
  id: vocoder_freedv_rx_ss
  parameters:
    interleave_frames: '1'
    mode: freedv_api.MODE_2400B
    squelch_enable: squelch_enable
    squelch_thresh: squelch_thresh
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: '0.4'
    interp: '6'
    type: fff
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_out
    samp_rate: audio_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '2048'
    name: '''Espectro recibido desde el HT'''
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '''Voz FreeDV decodificada'''
    size: '2048'
    srate: audio_rate
    type: float
  states: {}

connections:
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_short_0, '0', vocoder_freedv_rx_ss_0, '0']
- [vocoder_freedv_rx_ss_0, '0', blocks_short_to_float_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
